# Keil uVision project 电压频率采集设备.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 电压频率采集设备 +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: .\Src
  group Source Group 1
    ./: main.c
    ./Src/: iic.c ds1302.c
